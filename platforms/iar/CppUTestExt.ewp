# IAR project CppUTestExt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    ../../src/CppUTestExt/: CodeMemoryReportFormatter.cpp IEEE754ExceptionsPlugin.cpp MemoryReportAllocator.cpp MemoryReporterPlugin.cpp MemoryReportFormatter.cpp MockActualCall.cpp MockExpectedCall.cpp MockExpectedCallsList.cpp MockFailure.cpp MockNamedValue.cpp MockSupport.cpp MockSupport_c.cpp MockSupportPlugin.cpp OrderedTest.cpp
