# IAR project CppUTestExtTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CppUTestExtTest.srec
  ILINK.IlinkOutputFile: CppUTestExtTest.out
  ILINK.IlinkIcfFile: CppUTestExtTest.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\cpputest.a; Debug\Exe\cpputestext.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group tests
    ../../tests/CppUTestExt/: AllTests.cpp
  group tests/failing
    ../../tests/CppUTestExt/: CodeMemoryReporterTest.cpp IEEE754PluginTest.cpp IEEE754PluginTest_c.c
  group tests/passing
    ../../tests/CppUTestExt/: ExpectedFunctionsListTest.cpp GMockTest.cpp GTest1Test.cpp GTest2ConvertorTest.cpp MemoryReportAllocatorTest.cpp MemoryReporterPluginTest.cpp MemoryReportFormatterTest.cpp MockActualCallTest.cpp MockCallTest.cpp MockCheatSheetTest.cpp MockComparatorCopierTest.cpp MockExpectedCallTest.cpp MockFailureReporterForTest.cpp MockFailureTest.cpp MockHierarchyTest.cpp MockNamedValueTest.cpp MockParameterTest.cpp MockPluginTest.cpp MockReturnValueTest.cpp MockStrictOrderTest.cpp MockSupport_cTest.cpp MockSupport_cTestCFile.c MockSupportTest.cpp OrderedTestTest.cpp
