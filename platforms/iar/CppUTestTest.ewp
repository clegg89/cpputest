# IAR project CppUTestTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CppUTestTest.srec
  ILINK.IlinkOutputFile: CppUTestTest.out
  ILINK.IlinkIcfFile: CppUTestTest.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\cpputest.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group tests
    tests/: AllTests.cpp
  group tests/passing
    ../../tests/: AllocationInCFile.c AllocationInCppFile.cpp AllocLetTestFree.c AllocLetTestFreeTest.cpp CheatSheetTest.cpp CommandLineArgumentsTest.cpp CommandLineTestRunnerTest.cpp JUnitOutputTest.cpp MemoryLeakDetectorTest.cpp MemoryLeakWarningTest.cpp MemoryOperatorOverloadTest.cpp PluginTest.cpp PreprocessorTest.cpp SetPluginTest.cpp SimpleMutexTest.cpp SimpleStringTest.cpp TestFailureNaNTest.cpp TestFailureTest.cpp TestFilterTest.cpp TestHarness_cTest.cpp TestHarness_cTestCFile.c TestInstallerTest.cpp TestMemoryAllocatorTest.cpp TestOutputTest.cpp TestRegistryTest.cpp TestResultTest.cpp TestUTestMacro.cpp UtestPlatformTest.cpp UtestTest.cpp
